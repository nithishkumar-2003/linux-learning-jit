do_copy_target_rustlibs() {
    bbnote "Skipping do_copy_target_rustlibs to avoid missing rustlib error"
    # Do nothing to skip copying rust target libs
}

