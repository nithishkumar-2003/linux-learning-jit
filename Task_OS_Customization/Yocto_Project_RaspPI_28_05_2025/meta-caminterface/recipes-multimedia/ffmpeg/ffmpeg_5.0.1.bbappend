EXTRA_OECONF += " --enable-gpl "
