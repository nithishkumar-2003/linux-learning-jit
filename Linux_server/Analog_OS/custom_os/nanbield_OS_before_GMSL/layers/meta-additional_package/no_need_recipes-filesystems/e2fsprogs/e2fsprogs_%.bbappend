EXTRA_OECONF:append = " --disable-resize2fs"
