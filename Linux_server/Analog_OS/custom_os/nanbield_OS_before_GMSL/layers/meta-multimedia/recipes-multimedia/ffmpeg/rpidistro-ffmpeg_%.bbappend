PACKAGECONFIG:append:ffmpeg = " sdl2"
