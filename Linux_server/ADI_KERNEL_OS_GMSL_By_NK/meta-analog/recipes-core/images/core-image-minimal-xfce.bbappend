# core-image-minimal-xfce.bbappend

# Add overlays to boot partition files when creating rpi-sdimg
#BOOT_FILES += "boot/overlays/*.dtbo"

